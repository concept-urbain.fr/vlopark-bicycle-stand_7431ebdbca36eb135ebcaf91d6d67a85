Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Vélopark support vélo.IFC
Time: 2020-07-03T11:08:27
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: Vélopark support vélo
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 16.4787; Area Measure: 0.880597; Volume Measure: 0.00214009
